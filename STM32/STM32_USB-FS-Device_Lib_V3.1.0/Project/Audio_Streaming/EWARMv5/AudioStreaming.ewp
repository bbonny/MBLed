# IAR project AudioStreaming.ewp, settings and files
configuration STM3210C-EVAL-25MHz (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; EXTERNAL_CRYSTAL_25MHz
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: AudioStreaming.bin
  ILINK.IlinkOutputFile: AudioStreaming.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL-14MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; EXTERNAL_CRYSTAL_14_7456MHz; HSE_VALUE
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: audio_codec_cs43l22.c hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
